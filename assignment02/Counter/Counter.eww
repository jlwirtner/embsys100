<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\Counter.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\..\..\..\..\Users\Josh\Documents\demo\demo.ewp</path>
    </project>
    <batchBuild />
</workspace>
